# IAR project Backup of Practice1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; SerialPort; APP; Module\FlashIAP
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Practice1.hex
  ILINK.IlinkOutputFile: Practice_IAP.out
  ILINK.IlinkIcfFile: Linker\lnkstm8s103f3_BLD.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    APP/: main.c stm8s_it.c stm8s_it.h
  group Linker
    Linker/: lnkstm8s103f3_BLD.icf
  group Module/FlashIAP
    Module/FlashIAP/: Flash.c Flash.h
  group SerialPort
    SerialPort/: SerialPort.c SerialPort.h
  group STM8S_StdPeriph_Driver/inc
    STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_clk.h stm8s_conf.h stm8s_flash.h stm8s_gpio.h stm8s_tim2.h stm8s_uart1.h
  group STM8S_StdPeriph_Driver/src
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_tim2.c stm8s_uart1.c
